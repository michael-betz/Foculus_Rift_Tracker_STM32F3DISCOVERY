# Keil uVision project arm_cortexM0l_dotproduct_example.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: arm_cortexM0l_dotproduct_example
  group Source Group 1
    ../: arm_dotproduct_example_f32.c
  group CMSIS Device
    ../../Common/GCC/: startup_ARMCM0.s
    ../../Common/: system_ARMCM0.c
